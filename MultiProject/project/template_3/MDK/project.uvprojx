# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F0XX_LD,
  c include: ..\..\..\lib;..\..\common;..\..\common\HAL\CMSIS;..\..\common\HAL\FWLIB\inc;..\..\common\HAL;..\..\common\MPL;..\..\common\EPL;..\app
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group app
    ../app/: main.c
  group lib
    ../../../lib/ringbuf/: ringbuf.c
  group protocol
    ../app/protocol/: communication.c UsarDataDIS.c
  group FWLIB
    ../../common/HAL/FWLIB/src/: stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c stm32f0xx_adc.c
  group HAL
    ../../common/HAL/CMSIS/: system_stm32f0xx.c
    ../../common/HAL/startup/: startup_stm32f0xx.s
    ../../common/HAL/system/delay/: delay.c
    ../../common/HAL/system/sys/: sys.c
  group MPL
    ../../common/MPL/stmflash/: stmflash.c
    ../../common/MPL/tim/: tim.c
    ../../common/MPL/uart/: usart.c
  group EPL
    ../../common/EPL/fire/: fire.c
