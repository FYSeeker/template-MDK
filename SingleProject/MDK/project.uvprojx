# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\lib;..\module\HAL;..\module\HAL\CORE;..\module\HAL\FWLIB\inc;..\module\MPL;..\module\EPL;..\module\APL;..\app
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/: main.c DxlRegister.c DXL.c sensor.c imu.c
  group lib
    ../lib/ringbuf/: ringbuf.c
  group FWLIB
    ../module/HAL/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group HAL
    ../module/HAL/CORE/: startup_stm32f40_41xxx.s
    ../module/HAL/: stm32f4xx_it.c system_stm32f4xx.c
    ../module/HAL/system/sys/: sys.c
    ../module/HAL/system/delay/: delay.c
  group MPL
    ../module/MPL/exti/: exti.c
    ../module/MPL/uart/: uart1.c uart3.c
    ../module/MPL/tim/: tim.c
    ../module/MPL/adc/: adc.c
    ../module/MPL/iic/: hard_i2c.c soft_i2c.c s_iic.c
  group EPL
    ../module/EPL/led/: led.c
    ../module/EPL/key/: key.c
    ../module/EPL/VL53L0/: VL53L0.c vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_strings.c vl53l0x_cali.c vl53l0x_platform.c
    ../module/EPL/misrophone/: misrophone.c
    ../module/EPL/Buzzer/: Buzzer.c
    ../module/EPL/lsm6ds3tr/: lsm6ds3tr_c_reg.c lsm6ds3.c
    ../module/EPL/lsm303ah/: lsm303ah_reg.c LSM303C_MAG_driver.c
